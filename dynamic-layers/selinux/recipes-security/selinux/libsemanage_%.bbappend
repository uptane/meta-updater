POLICY_STORE_ROOT:sota = "${sysconfdir}/selinux"
