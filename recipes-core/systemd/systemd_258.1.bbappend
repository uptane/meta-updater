FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:sota = " file://0001-boot-handle-empty-initrd-files-40040.patch"
