# Apply the composefs kernel configuration to kernel recipes named linux-*
# (linux-yocto, linux-intel, linux-qcom, ...); see composefs.inc.
require composefs.inc
